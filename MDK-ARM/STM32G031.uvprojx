# Keil uVision project STM32G031.uvprojx, settings and files
target STM32G031 (6190000::V6.19::ARMCLANG)
  device: STM32G031G8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G031 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ./: Svpwm.c Svpwm.h TIMxPWM.c TIMxPWM.h FocCommon.h FOC.c FOC.h sincos.c sincos.h
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
